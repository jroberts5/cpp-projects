<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\electronics_circuit design\embedded-programming\lesson1\project.ewp</path>
    </project>
    <batchBuild />
</workspace>
